# Keil uVision project STM32F10x_RTOS.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F10x_RTOS
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: ..\CMSIS;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\ARM_CM3;..\STM32F10x_Libs\inc;..\User;..\Basic\usart;..\Basic\Key_Scan;..\Basic\Display;..\Basic\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s stm32f10x.h
    ../User/: stm32f10x_conf.h
  group STM32F10x_Libs
    ../STM32F10x_Libs/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ../FreeRTOS/Source/: list.c queue.c tasks.c event_groups.c timers.c
    ../FreeRTOS/Source/portable/ARM_CM3/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Basic
    ../Basic/usart/: bsp_usart.c
    ../Basic/Key_Scan/: CodingsWitch_scan.c bsp_key.c
    ../Basic/Display/: bsp_led.c bsp_motor.c
    ../Basic/OLED/: delay.c bsp_oled.c
  group User
    ../User/: main.c FreeRTOSConfig.h Stm32_System_Init.c stm32f10x_it.c
